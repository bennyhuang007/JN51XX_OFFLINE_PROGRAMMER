# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CPU\CMSIS\Include; ..\CPU\CMSIS\Device\Include; ..\CPU\STM32_USB-FS-Device_Driver\inc; ..\CPU\STM32F10x_StdPeriph_Driver\inc; ..\uC-CPU; ..\uC-CPU\ARM-Cortex-M3\IAR; ..\uC-LIB; ..\uCOS-II\Ports\arm-cortex-m3\Generic\IAR; ..\uCOS-II\Source; ..\Users\APP; ..\Users\BSP; ..\Users\FIFO; ..\Users\FatFS; ..\Users\DRIVER\USART; ..\Users\DRIVER\USB\inc; ..\Users\DRIVER\SPI_FLASH
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: ..\Users\BSP\STM32F103ZE_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  OBJCOPY.OOCOutputFile: Template.srec
  group (top)
    ../Users/BSP/: STM32F103ZE_FLASH.icf
  group CPU/CMSIS
    ../CPU/CMSIS/Device/Source/: system_stm32f10x.c
  group CPU/STM32F10x_StdPeriph_Driver/inc
    ../CPU/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CPU/STM32F10x_StdPeriph_Driver/src
    ../CPU/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CPU/USB-FS-Device_Driver/inc
    ../CPU/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group CPU/USB-FS-Device_Driver/src
    ../CPU/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group uC-CPU
    ../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../uC-CPU/: cpu_def.h
  group uC-LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-II/Ports
    ../uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group USERS/APP
    ../Users/APP/: app_adc.c app_adc.h app_cfg.h app_main.c app_taskchipx.c app_taskchipx.h app_taskmem.c app_taskmem.h app_taskui.c app_taskui.h bl_statemachine.cpp bl_statemachine.hpp common.c common.h ErrCode.h includes.h log.c log.h os_cfg.h ram_code.h read_config_file.c read_config_file.h stm32f10x_conf.h
  group USERS/BSP
    ../Users/APP/: app_vect_v5.c
    ../Users/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group USERS/DRIVER/SPI_FLASH
    ../Users/DRIVER/SPI_FLASH/: spi_flash.c spi_flash.h
  group USERS/DRIVER/USART
    ../Users/DRIVER/USART/: usart_driver.h usart_driver_dma.c
  group USERS/DRIVER/USB/inc
    ../Users/DRIVER/USB/inc/: flash_if.h hw_config.h mass_mal.h memory.h usb_bot.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h usb_scsi.h
  group USERS/DRIVER/USB/src
    ../Users/DRIVER/USB/src/: flash_if.c hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USERS/FatFS
    ../Users/FatFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group USERS/FIFO
    ../Users/FIFO/: fifo.c fifo.h
